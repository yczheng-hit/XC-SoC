# Keil uVision project XC-SoC.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: main
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe ./main.axf --vhx --32x1 --output main.hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe ./main.axf -o main.txt
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M0
  c include: ..\..\..\..\software\cmsis\CMSIS\Include; ..\..\..\..\software\cmsis\Device\ARM\CMSDK_CM0\Include; ..\..\..\..\software\common\retarget
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry Reset_Handler
  group Startup
    ./: startup_CMSDK_CM0.s
  group Application
    ../: main.c uart_api.c vga_api.c spi_api.c
software components: CMSIS:CORE 5.0.1
